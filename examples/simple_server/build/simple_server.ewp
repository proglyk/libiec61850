# IAR project simple_server.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; USE_HAL_DRIVER
  ICCARM.IExtraOptions: --stack_protection
  ICCARM.CCIncludePath2: $WS_DIR$\include; $WS_DIR$\include\sys; $WS_DIR$\..\..\include; $WS_DIR$\..\..\lib\HAL\inc; $WS_DIR$\..\..\third\FreeRTOS; $WS_DIR$\..\..\third\FreeRTOS\port; $WS_DIR$\..\..\third\FreeRTOS\core\header; $WS_DIR$\..\..\lib\NET
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $WS_DIR$\..\..\include
  OBJCOPY.OOCOutputFile: $WS_DIR$\bin\simple_server.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect free=vPortFree; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc
  ILINK.IlinkAdditionalLibs: $WS_DIR$\..\..\lib\HAL\HAL.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group example
    ../src/: debug3.c main.c
  group example/sys
    ../src/sys/: stack_protection.c startup_stm32f407xx.s stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c stm32f4xx_it_cb.c system_stm32f4xx.c
  group lib/HAL
    ../../../lib/HAL/: stm32f4xx_hal_eth.c
  group third
    ../../../third/FreeRTOS/: cmsis_os.c
  group third/core
    ../../../third/FreeRTOS/core/source/: list.c queue.c tasks.c timers.c
  group third/port
    ../../../third/FreeRTOS/port/: heap_4.c port.c portasm.s
